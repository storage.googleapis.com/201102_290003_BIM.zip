Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50356248-56fd-404e-bfe4-5503dd407272, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 290003.ifc
Time: 2025-01-29T23:48:37
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 290003:290003 Spout, L=150, 290003:290003 Spout, L=150:396045
In: Level 1
Type - PredefinedType: FAUCET; Material: <Unnamed>
Type - General - Author: BIMStone; BIMObjectName: 290003; ManufacturerName: Oras Group; ManufacturerURL: http://www.oras group.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_97; Uniclass2015Description: Washbasin spouts; Uniclass2015Reference: Pr_40_20_87_97; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - ETIM Class Number: EC011421 Outlet for sanitary taps; LVI Number: 6510294; NRF Number: 4205438; RSK Number: 8441000; UNSPSC Class Number: 30181807 Spout; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; VVS Number: 745142444
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Spout Projection: 150 mm; Spout Type: Swivel spout;Casted construction; Surface treatment: Chrome
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Dimensions - NominalDepth: 177.3 mm; NominalHeight: 58.1 mm; NominalWidth: 29 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/290003; Catalog Drawing URL: http://static.oras.com/catdrw/290003; Category B2B: Health & Care;Accessories; FDV Document URL: http://www.oras.com/datasheet/290003/en/fdv; Group: Spout; Interactive AR View URL: https://static.oras.com/AR/290003; Long Marketing: Designed for all Clinica wall mounted faucets with easy click connection; Manufacturer: Oras Group; Market: Austria;Belgium;Czech Republic;Germany;Denmark;Spain;Estonia;Finland;France;International;Italy;Lithuania;Latvia;Netherlands;Norway;Poland;Slovakia;Sweden; Mobile Product Information URL: http://mpi.oras.com/290003; Model: 290003 Spout, L=150; Name_en: 290003 Spout, L=150; OmniClass Number: 23.45.55.00; Product Code: 290003; Product Family: Oras Group; Product Image URL: http://static.oras.com/image/290003; Product URL: http://static.oras.com/290003; Spare-Part Information URL: http://static.oras.com/sp/290003; Technical DataSheet URL: http://www.oras.com/datasheet/290003/en; Type Name: 290003 Spout, L=150; Usage Group: Sweden; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras Group; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 290003; Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 290003; Name: 290003 Spout, L=150; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 290003; Manufacturer: Oras Group
Type - Pset_ProductRequirements - Name: 290003 Spout, L=150
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 290003 Spout, L=150; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0171126 m2; Volume: 0.000298366 m3
Identity Data - Mark: 22
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 290003; Family and Type: 290003: 290003 Spout, L=150; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 290003 Spout, L=150; Type Id: 396029; WarrantyStartDate: n/a
